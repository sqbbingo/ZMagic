# IAR project template.ewp, settings and files
configuration template (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT=1; __FPU_USED=1; STM32F40_41xxx; _DLIB_FILE_DESCRIPTOR=1; USE_STDPERIPH_DRIVER; xWITH_IPV6; xWITH_II_802154; xWITH_RPL; DEV_TYPE=1; __ICCARM__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\core; ..\..\..\..\..\core\net; ..\..\..\..\..\core\net\mac; ..\..\..\..\..\core\net\rpl; ..\..\..\..\..\core\net\rime; ..\..\..\..\..\apps; ..\..\..\..\..\apps\shell; ..\..\..\..\..\apps\serial-shell; ..\..\..\common\FML\fml_key; ..\..\..\common\HAL\stm32f407\clock; ..\..\..\common; ..\..\..\common\FML\fml_uart; ..\..\..\common\APL\apl_debug; ..\..\..\common\FML\fml_spi; ..\..\..\common\FML\fml_sd; ..\..\..\common\MPL\mpl_iic; ..\..\..\common\MPL\mpl_spi; ..\..\..\common\MPL\mpl_uart; ..\..\..\common\FML\fml_relay; ..\..\..\common\FML\fml_w25qxx; ..\..\..\common\FML\fml_wk2xxx; ..\..\..\common\MPL\mpl_fsmc; ..\..\..\common\FML\fml_rf; ..\..\..\common\APL\apl_rf\zxbee; ..\..\app\sensor; ..\..\..\common\APL\apl_power; ..\..\..\common\MPL\mpl_dcmi; ..\..\..\common\FML\fml_camera\OV2640; ..\..\..\common\APL\FATFS; ..\..\app\UIL; ..\..\app\SLL\sensor; ..\..\..\common\APL\apl_rf\lte; ..\..\..\common\APL\apl_key; ..\..\..\common\FML\fml_audio; ..\..\..\common\HAL\stm32f407\cmsis\Include; ..\..\..\common\MPL\mpl_exti; ..\..\app\desktop; ..\..\app\phone; ..\..\..\common\APL\apl_camera; ..\..\..\common\FML\fml_date; ..\..\..\common\APL\apl_SysCalendar; ..\..\app\SLL\inc; ..\..\..\common\APL\mp3\pub; ..\..\..\common\APL\mp3\real; ..\..\app\UIL\inc; ..\..\..\common\APL\apl_font; ..\..\..\common\FML\fml_finger; ..\..\..\common\MPL\mpl_adc; ..\..\..\common\APL\apl_picture; ..\..\..\common\APL\apl_rf; ..\..\app; ..\..\..\common\APL\apl_cpu; ..\..\..\common\APL\STemWinLibrary532\Config; ..\..\..\common\APL\STemWinLibrary532\inc; ..\..\..\common\FML; ..\..\..\common\MPL; ..\..\app\App\inc; ..\..\..\common\APL\qrencode; ..\..\..\..\common\HAL\stm32f407\clock; ..\..\..\..\common\HAL\stm32f407\cmsis\Include; ..\..\..\..\common\HAL\stm32f407\FWLIB\inc; ..\..\..\..\common\HAL\stm32f407; ..\..\..\..\common\HAL\stm32f407\FWLIB; ..\..\..\..\..\..\core; ..\..\..\..\..\..\apps\shell; ..\..\..\common\APL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../app/readme/: readme.html
  group app/serial-shell
    ../../../../../../apps/serial-shell/: serial-shell.c
  group app/shell
    ../../../../../../apps/shell/: shell.c
  group core/dev
    ../../../../../../core/dev/: leds.c nullradio.c
  group core/lib
    ../../../../../../core/lib/: assert.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c print-stats.c random.c ringbuf.c settings.c trickle-timer.c
  group core/sys
    ../../../../../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c process.c procinit.c rtimer.c stimer.c timer.c
  group zonesion
    ../../app/: contiki-conf.h contiki-main.c
  group zonesion/app
    ../../app/: autoapps.c helloworld.c sensor_process.c
  group zonesion/app/App
    ../../app/App/src/: App.c AppListDLG.c DesktopDLG.c ErrorDLG.c StatusBarDLG.c View.c
  group zonesion/app/App/icon
    ../../app/App/icon/: app_60X60.c Camera_60X60.c Phone_60X60.c Setting_60X60.c
  group zonesion/app/sensor
    ../../app/sensor/: sensor.c
  group zonesion/common/APL/apl_cpu
    ../../../common/APL/apl_cpu/: apl_cpu.c
  group zonesion/common/APL/apl_debug
    ../../../common/APL/apl_debug/: debug.c
  group zonesion/common/APL/apl_font
    ../../../common/APL/apl_font/: GUIFont_Port.c
  group zonesion/common/APL/apl_key
    ../../../common/APL/apl_key/: apl_key.c
  group zonesion/common/APL/apl_led
    ../../../common/APL/apl_led/: LedProcess.c
  group zonesion/common/APL/apl_picture
    ../../../common/APL/apl_picture/: apl_picture.c
  group zonesion/common/APL/apl_power
    ../../../common/APL/apl_power/: BatteryVoltage.c
  group zonesion/common/APL/apl_rf
    ../../../common/APL/apl_rf/: hw.c rfUart.c
  group zonesion/common/APL/apl_rf/apl_ble
    ../../../common/APL/apl_rf/ble/: ble-net.c
  group zonesion/common/APL/apl_rf/apl_lte
    ../../../common/APL/apl_rf/lte/: lte-ec20.c lte-inf.c lte-tcp.c lte_zhiyun.c
  group zonesion/common/APL/apl_rf/apl_zxbee
    ../../../common/APL/apl_rf/zxbee/: zxbee.c
  group zonesion/common/APL/apl_rf/at
    ../../../common/APL/apl_rf/at/: at-uart.c at.c UserAt.c
  group zonesion/common/APL/apl_sysCalender
    ../../../common/APL/apl_SysCalendar/: SysCalendar.c
  group zonesion/common/APL/FATFS
    ../../../common/APL/FATFS/: diskio.c ff.c
  group zonesion/common/APL/FATFS/option
    ../../../common/APL/FATFS/option/: cc936.c
  group zonesion/common/APL/MP3
    ../../../common/APL/mp3/: mp3dec.c mp3tabs.c
  group zonesion/common/APL/MP3/real
    ../../../common/APL/mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
  group zonesion/common/APL/MP3/real/arm
    ../../../common/APL/mp3/real/arm/: asmmisc.s asmpoly_thumb2.s
  group zonesion/common/APL/QREncode
    ../../../common/APL/qrencode/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group zonesion/common/APL/STemWin/config
    ../../../common/APL/STemWinLibrary532/OS/: GUI_X.c
    ../../../common/APL/STemWinLibrary532/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
  group zonesion/common/APL/STemWin/lib
    ../../../common/APL/STemWinLibrary532/Lib/: STemWin532_CM4_IAR.a
  group zonesion/common/FML/fml_audio
    ../../../common/FML/fml_audio/: audioAmplifier.c bsp_wm8978.c
  group zonesion/common/FML/fml_camera/OV2640
    ../../../common/FML/fml_camera/OV2640/: ov2640.c sccb.c
  group zonesion/common/FML/fml_date
    ../../../common/FML/fml_date/: pcf8563.c
  group zonesion/common/FML/fml_finger
    ../../../common/FML/fml_finger/: finger.c
  group zonesion/common/FML/fml_gps
    ../../../common/FML/fml_gps/: GPS.c
  group zonesion/common/FML/fml_imu
    ../../../common/FML/fml_imu/: lis3dh.c
  group zonesion/common/FML/fml_key
    ../../../common/FML/fml_key/: fml_key.c
  group zonesion/common/FML/fml_lcd
    ../../../common/FML/fml_lcd/: fml_lcd.c ft6x36.c ST7789.c
  group zonesion/common/FML/fml_led
    ../../../common/FML/fml_led/: fml_led.c
  group zonesion/common/FML/fml_light
    ../../../common/FML/fml_light/: apds9900.c
  group zonesion/common/FML/fml_relay
    ../../../common/FML/fml_relay/: relay.c
  group zonesion/common/FML/fml_sd
    ../../../common/FML/fml_sd/: sd_spi.c
  group zonesion/common/FML/fml_SerialExt
    ../../../common/FML/fml_wk2xxx/: wk2xxx.c
  group zonesion/common/FML/fml_SpiFlash
    ../../../common/FML/fml_w25qxx/: w25qxx.c
  group zonesion/common/FML/fml_VibratingMotor
    ../../../common/FML/fml_VibratingMotor/: VibratingMotor.c
  group zonesion/common/HAL/stm32f407
    ../../../../common/HAL/stm32f407/FWLIB/: system_stm32f4xx.c
  group zonesion/common/HAL/stm32f407/clock
    ../../../../common/HAL/stm32f407/clock/: clock.c delay.c rtimer-arch.c
  group zonesion/common/HAL/stm32f407/cmsis
    ../../../../common/HAL/stm32f407/cmsis/Lib/ARM/: arm_cortexM4lf_math.lib iar_cortexM4lf_math.a
  group zonesion/common/HAL/stm32f407/fwlib
    ../../../../common/HAL/stm32f407/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group zonesion/common/HAL/stm32f407/starup
    ../../../../common/HAL/stm32f407/startup/: startup_stm32f40xx.s
  group zonesion/common/MPL/mpl_adc
    ../../../common/MPL/mpl_adc/: adc.c
  group zonesion/common/MPL/mpl_dcmi
    ../../../common/MPL/mpl_dcmi/: dcmi.c
  group zonesion/common/MPL/mpl_exti
    ../../../common/MPL/mpl_exti/: exti.c
  group zonesion/common/MPL/mpl_fsmc
    ../../../common/MPL/mpl_fsmc/: fsmc.c
  group zonesion/common/MPL/mpl_iic
    ../../../common/MPL/mpl_iic/: soft_iic.c soft_iic1.c
  group zonesion/common/MPL/mpl_spi
    ../../../common/MPL/mpl_spi/: spi1.c
  group zonesion/common/MPL/mpl_tim
    ../../../common/MPL/mpl_tim/: bsp_tim.c
  group zonesion/common/MPL/mpl_uart
    ../../../common/MPL/mpl_uart/: uart1.c uart2.c uart4.c usart6.c
